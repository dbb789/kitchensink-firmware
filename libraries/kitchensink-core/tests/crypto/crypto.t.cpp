#include "gtest/gtest.h"

#include "types/arrayoutstream.h"
#include "types/datarefinstream.h"
#include "types/dataref.h"
#include "types/strref.h"
#include "crypto/cryptoinstream.h"
#include "crypto/cryptooutstream.h"
#include "crypto/entropypool.h"

#include <ostream>

static void PrintTo(const DataRef& dataRef,
                    std::ostream*  os)
{
    *os << "Size=" << dataRef.size() << " ";
    
    for (auto d : dataRef)
    {
        *os << (int)d << " ";
    }
}

namespace
{
// D(key, E(key, data)) = data
void sanityCheck(const DataRef& testData,
                 const StrRef&  password,
                 int            prngSeed)
{
    // rand() is a PRNG so don't even think about doing this in real code!
    srand(prngSeed);
    
    Crypto::IV iv;
    Crypto::IV dataIv;
    Crypto::Key dataKey;

    for (auto& x : iv)
    {
        x = uint8_t(rand() & 0xff);
    }

    for (auto& x : dataIv)
    {
        x = uint8_t(rand() & 0xff);
    }
        
    for (auto& x : dataKey)
    {
        x = uint8_t(rand() & 0xff);
    }

    std::array<uint8_t, 1024 * 1024> encryptedData;
    ArrayOutStream encryptedOut(encryptedData);

    {
        CryptoOutStream cryptOut(encryptedOut, password, "_kitchenSink", iv, dataIv, dataKey);

        cryptOut.write(testData);
    }

    ASSERT_GT(encryptedOut.position(), testData.size());

    DataRefInStream encryptedIn(encryptedOut.data());
    
    CryptoInStream cryptIn(encryptedIn, password, "_kitchenSink");
    
    std::array<uint8_t, 1024 * 1024> decryptedData;
    ArrayOutStream decryptedOut(decryptedData);

    std::size_t size(0);
    
    while (true)
    {
        auto read(cryptIn.read(decryptedOut, decryptedOut.remaining()));

        if (read == 0)
        {
            break;
        }
        
        size += read;
    }

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kValidated);
    
    ASSERT_EQ(testData.size(), size);
    ASSERT_EQ(decryptedOut.data(), testData);
}

}

TEST(Crypto, Sanity0)
{
    const uint8_t TestDataRaw[] =
    {
        0, 1, 2, 3
    };
    
    DataRef testData(TestDataRaw, TestDataRaw + sizeof(TestDataRaw));
    StrRef password("test");
    
    sanityCheck(testData, password, 0);
}

TEST(Crypto, Sanity1)
{
    const uint8_t TestDataRaw[] =
    {
        0, 1, 2, 3, 4, 5, 6, 7,
        8, 9, 10, 11, 12, 13, 14, 15
    };
    
    DataRef testData(TestDataRaw, TestDataRaw + sizeof(TestDataRaw));
    StrRef password("password!123");
    
    sanityCheck(testData, password, 123);
}

TEST(Crypto, Sanity2)
{
    const uint8_t TestDataRaw[] =
    {
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x50,0x00,0x00,0x00,
        0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x20,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x48,0x00,0x20,0x50,0x50,0x20,0x48,0x20,0x20,0x10,0x40,0x00,
        0x00,0x00,0x00,0x00,0x08,0x70,0x20,0x70,0x70,0x08,0xf8,0x70,0xf8,0x70,0x70,0x00,0x00,0x00,0x00,0x00,
        0x70,0x70,0x70,0xf0,0x70,0xe0,0xf8,0xf8,0x70,0x88,0x70,0x38,0x88,0x80,0x88,0x88,0x70,0xf0,0x70,0xf0,
        0x70,0xf8,0x88,0x88,0x88,0x88,0x88,0xf8,0x70,0x40,0x70,0x50,0x00,0x00,0x00,0x80,0x00,0x08,0x00,0x18,
        0x00,0x80,0x20,0x08,0x40,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00,
        0x18,0x20,0x60,0xa8,0x0c,0x20,0x50,0x50,0x70,0xa8,0x50,0x20,0x20,0x20,0x00,0x00,0x00,0x00,0x00,0x08,
        0x88,0x60,0x88,0x88,0x18,0x80,0x80,0x08,0x88,0x88,0x00,0x00,0x08,0x00,0x40,0x88,0x88,0x88,0x88,0x88,
        0x90,0x80,0x80,0x88,0x88,0x20,0x10,0x90,0x80,0xd8,0x88,0x88,0x88,0x88,0x88,0x88,0x20,0x88,0x88,0x88,
        0x88,0x88,0x08,0x40,0x40,0x10,0x88,0x00,0x00,0x00,0x80,0x00,0x08,0x00,0x20,0x00,0x80,0x00,0x00,0x40,
        0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x20,0x10,0x90,0x0c,
        0x20,0x00,0xf8,0xa8,0x50,0x50,0x00,0x40,0x10,0x50,0x20,0x00,0x00,0x00,0x10,0x98,0x20,0x88,0x08,0x28,
        0x80,0x80,0x08,0x88,0x88,0x20,0x20,0x10,0xf8,0x20,0x88,0x98,0x88,0x88,0x80,0x88,0x80,0x80,0x80,0x88,
        0x20,0x10,0xa0,0x80,0xa8,0xc8,0x88,0x88,0x88,0x88,0x80,0x20,0x88,0x88,0x88,0x50,0x50,0x10,0x40,0x20,
        0x10,0x00,0x00,0x00,0x70,0xf0,0x70,0x78,0x70,0x70,0x78,0xf0,0x60,0x18,0x48,0x20,0xf0,0xf0,0x70,0xf0,
        0x78,0xb8,0x78,0x70,0x88,0x88,0x88,0x88,0x88,0xf8,0x20,0x20,0x10,0x00,0x18,0x20,0x00,0x50,0xa0,0x10,
        0x20,0x00,0x40,0x10,0x20,0x20,0x00,0x00,0x00,0x10,0xa8,0x20,0x08,0x30,0x48,0xf0,0xf0,0x10,0x70,0x88,
        0x20,0x20,0x20,0x00,0x10,0x10,0xa8,0x88,0xf0,0x80,0x88,0xf0,0xf0,0x80,0xf8,0x20,0x10,0xc0,0x80,0xa8,
        0xa8,0x88,0x88,0x88,0x88,0x70,0x20,0x88,0x50,0x88,0x20,0x50,0x20,0x40,0x20,0x10,0x00,0x00,0x00,0x08,
        0x88,0x88,0x88,0x88,0x20,0x88,0x88,0x20,0x08,0x50,0x20,0xa8,0x88,0x88,0x88,0x88,0xc0,0x80,0x20,0x88,
        0x88,0x88,0x50,0x88,0x10,0x40,0x20,0x08,0x00,0xd8,0x20,0x00,0x50,0x70,0x20,0x68,0x00,0x40,0x10,0xf8,
        0xf8,0x00,0xf8,0x00,0x20,0xc8,0x20,0x10,0x08,0x88,0x08,0x88,0x10,0x88,0x78,0x00,0x00,0x40,0x00,0x08,
        0x20,0xa8,0xf8,0x88,0x80,0x88,0x80,0x80,0xb8,0x88,0x20,0x10,0xc0,0x80,0x88,0x98,0x88,0xf0,0x88,0xf0,
        0x08,0x20,0x88,0x50,0xa8,0x20,0x20,0x40,0x40,0x10,0x10,0x00,0x00,0x00,0x78,0x88,0x80,0x88,0xf8,0x20,
        0x88,0x88,0x20,0x08,0x60,0x20,0xa8,0x88,0x88,0x88,0x88,0x80,0x70,0x20,0x88,0x50,0xa8,0x20,0x88,0x20,
        0x20,0x20,0x10,0x00,0xf0,0x00,0x00,0xf8,0x28,0x28,0x90,0x00,0x40,0x10,0x20,0x20,0x00,0x00,0x00,0x20,
        0x88,0x20,0x20,0x08,0xf8,0x08,0x88,0x20,0x88,0x08,0x00,0x00,0x20,0xf8,0x10,0x00,0x98,0x88,0x88,0x80,
        0x88,0x80,0x80,0x88,0x88,0x20,0x90,0xa0,0x80,0x88,0x88,0x88,0x80,0x88,0xa0,0x08,0x20,0x88,0x50,0xa8,
        0x50,0x20,0x80,0x40,0x10,0x10,0x00,0x00,0x00,0x88,0x88,0x80,0x88,0x80,0x20,0x88,0x88,0x20,0x08,0x60,
        0x20,0xa8,0x88,0x88,0x88,0x88,0x80,0x08,0x20,0x88,0x50,0xa8,0x20,0x88,0x40,0x20,0x20,0x10,0x00,0x70,
        0x20,0x00,0x50,0xa8,0x54,0x90,0x00,0x20,0x20,0x50,0x20,0x20,0x00,0x20,0x40,0x88,0x20,0x40,0x88,0x08,
        0x88,0x88,0x20,0x88,0x08,0x20,0x20,0x10,0x00,0x20,0x20,0x80,0x88,0x88,0x88,0x90,0x80,0x80,0x88,0x88,
        0x20,0x90,0x90,0x80,0x88,0x88,0x88,0x80,0xa8,0x90,0x88,0x20,0x88,0x20,0xd8,0x88,0x20,0x80,0x40,0x08,
        0x10,0x00,0x00,0x00,0x88,0x88,0x88,0x88,0x80,0x20,0x88,0x88,0x20,0x08,0x50,0x20,0xa8,0x88,0x88,0x88,
        0x88,0x80,0x08,0x20,0x88,0x20,0xa8,0x50,0x88,0x80,0x20,0x20,0x10,0x00,0x60,0x20,0x00,0x50,0x70,0x48,
        0x68,0x00,0x10,0x40,0x00,0x00,0x20,0x00,0x20,0x40,0x70,0x70,0xf8,0x70,0x08,0x70,0x70,0x20,0x70,0x70,
        0x20,0x20,0x08,0x00,0x40,0x20,0x78,0x88,0xf0,0x70,0xe0,0xf8,0x80,0x70,0x88,0x70,0x60,0x88,0xf8,0x88,
        0x88,0x70,0x80,0x70,0x88,0x70,0x20,0x70,0x20,0x88,0x88,0x20,0xf8,0x70,0x08,0x70,0x00,0x00,0x00,0x78,
        0xf0,0x70,0x78,0x78,0x20,0x78,0x88,0x70,0x08,0x48,0x70,0xa8,0x88,0x70,0xf0,0x78,0x80,0xf0,0x18,0x78,
        0x20,0x70,0x88,0x78,0xf8,0x18,0x20,0x60,0x00,0x60,0x00,0x00,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xf8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x08,0x00,0x00,0x48,0x00,0x00,0x00,0x00,0x00,0x80,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x70,0x00,0x00,0x30,0x00,
        0x00,0x00,0x00,0x00,0x80,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x70,0x00,0x00,0x00,0x00,0x00,0x00,
    };

    DataRef testData(TestDataRaw, TestDataRaw + sizeof(TestDataRaw));
    StrRef password("The quick brown fox jumps over the lazy dog");
    sanityCheck(testData, password, 456);
}

TEST(Crypto, Sanity3)
{
     // Prime to avoid matching any block size.
    static const size_t HugeSize = 524287;
    
    uint8_t* testDataRaw = new uint8_t[HugeSize];

    srand(123);
    
    for (size_t i = 0; i < HugeSize; ++i)
    {
        testDataRaw[i] = rand() & 0xff;
    }
    
    DataRef testData(testDataRaw, testDataRaw + HugeSize);
    StrRef password("Another password!123");
    sanityCheck(testData, password, 789);

    delete [] testDataRaw;
}

TEST(Crypto, AesCryptRead)
{
    // hello_world.txt from https://www.aescrypt.com/aes_stream_format.html
    // Contains "Hello, World!" encrypted with AES Crypt v3, password "apples".
    const uint8_t TestDataRaw[] =
    {
        0x41, 0x45, 0x53, 0x03, 0x00, 0x00, 0x1F, 0x43, 0x52, 0x45, 0x41, 0x54,
        0x45, 0x44, 0x5F, 0x42, 0x59, 0x00, 0x61, 0x65, 0x73, 0x63, 0x72, 0x79,
        0x70, 0x74, 0x5F, 0x63, 0x6C, 0x69, 0x20, 0x34, 0x2E, 0x30, 0x2E, 0x30,
        0x2E, 0x30, 0x00, 0x00, 0x00, 0x04, 0x93, 0xE0, 0x94, 0x70, 0x21, 0xF8,
        0xEE, 0xB3, 0x2E, 0xA4, 0x4E, 0xA8, 0x23, 0x72, 0x0A, 0x91, 0x2A, 0x18,
        0xD5, 0xEC, 0x63, 0xF1, 0x41, 0x7B, 0x77, 0x37, 0xB0, 0x0C, 0x45, 0x0C,
        0xE3, 0xA6, 0xCE, 0x10, 0x77, 0x89, 0x78, 0x95, 0xED, 0x48, 0xB4, 0x56,
        0x7A, 0x36, 0x04, 0x62, 0xFB, 0x24, 0x2D, 0x5C, 0x8A, 0xBC, 0x44, 0x8D,
        0x47, 0x85, 0x2E, 0xEB, 0x9D, 0xC3, 0xB7, 0x91, 0x1F, 0x4B, 0xF0, 0x02,
        0xE9, 0xEE, 0x26, 0xBF, 0xEA, 0x2F, 0xFC, 0x47, 0x12, 0xD3, 0x61, 0x98,
        0x85, 0x50, 0x53, 0x45, 0xF5, 0x35, 0x73, 0x63, 0xD9, 0x0B, 0x6A, 0x2F,
        0xAC, 0x2B, 0x37, 0xD1, 0xDB, 0x8F, 0x34, 0xF6, 0x06, 0xA2, 0xDE, 0x1E,
        0x8C, 0x66, 0x2A, 0x94, 0xC0, 0x3B, 0x15, 0xFD, 0xF9, 0x4A, 0xCE, 0x23,
        0x83, 0x5B, 0x90, 0x9E, 0x3F, 0xEF, 0x96, 0xA7, 0x07, 0x14, 0x11, 0xFD,
        0x72, 0x51, 0x78, 0x62, 0xCB, 0x00, 0x8C, 0xB5, 0x90, 0xA4, 0x05, 0x65,
        0x4B, 0xA8, 0xD3, 0xA7, 0x18, 0xD3, 0xA8, 0xFA
    };

    DataRef testData(TestDataRaw, TestDataRaw + sizeof(TestDataRaw));
    DataRefInStream encryptedIn(testData);

    CryptoInStream cryptIn(encryptedIn, "apples", "");

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kReading);

    std::array<uint8_t, 1024> data;
    ArrayOutStream dataOut(data);

    auto dataSize(cryptIn.read(dataOut, 1024));

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kValidated);

    const uint8_t ExpectedDataRaw[] =
    {
        'H', 'e', 'l', 'l', 'o', ',', ' ', 'W', 'o', 'r', 'l', 'd', '!', '\n'
    };

    ASSERT_EQ(DataRef(data.begin(), data.begin() + dataSize),
              DataRef(ExpectedDataRaw, ExpectedDataRaw + sizeof(ExpectedDataRaw)));
}

TEST(Crypto, AesCryptReadBadPassword)
{
    // Same hello_world.txt v3 data, but with the wrong password.
    const uint8_t TestDataRaw[] =
    {
        0x41, 0x45, 0x53, 0x03, 0x00, 0x00, 0x1F, 0x43, 0x52, 0x45, 0x41, 0x54,
        0x45, 0x44, 0x5F, 0x42, 0x59, 0x00, 0x61, 0x65, 0x73, 0x63, 0x72, 0x79,
        0x70, 0x74, 0x5F, 0x63, 0x6C, 0x69, 0x20, 0x34, 0x2E, 0x30, 0x2E, 0x30,
        0x2E, 0x30, 0x00, 0x00, 0x00, 0x04, 0x93, 0xE0, 0x94, 0x70, 0x21, 0xF8,
        0xEE, 0xB3, 0x2E, 0xA4, 0x4E, 0xA8, 0x23, 0x72, 0x0A, 0x91, 0x2A, 0x18,
        0xD5, 0xEC, 0x63, 0xF1, 0x41, 0x7B, 0x77, 0x37, 0xB0, 0x0C, 0x45, 0x0C,
        0xE3, 0xA6, 0xCE, 0x10, 0x77, 0x89, 0x78, 0x95, 0xED, 0x48, 0xB4, 0x56,
        0x7A, 0x36, 0x04, 0x62, 0xFB, 0x24, 0x2D, 0x5C, 0x8A, 0xBC, 0x44, 0x8D,
        0x47, 0x85, 0x2E, 0xEB, 0x9D, 0xC3, 0xB7, 0x91, 0x1F, 0x4B, 0xF0, 0x02,
        0xE9, 0xEE, 0x26, 0xBF, 0xEA, 0x2F, 0xFC, 0x47, 0x12, 0xD3, 0x61, 0x98,
        0x85, 0x50, 0x53, 0x45, 0xF5, 0x35, 0x73, 0x63, 0xD9, 0x0B, 0x6A, 0x2F,
        0xAC, 0x2B, 0x37, 0xD1, 0xDB, 0x8F, 0x34, 0xF6, 0x06, 0xA2, 0xDE, 0x1E,
        0x8C, 0x66, 0x2A, 0x94, 0xC0, 0x3B, 0x15, 0xFD, 0xF9, 0x4A, 0xCE, 0x23,
        0x83, 0x5B, 0x90, 0x9E, 0x3F, 0xEF, 0x96, 0xA7, 0x07, 0x14, 0x11, 0xFD,
        0x72, 0x51, 0x78, 0x62, 0xCB, 0x00, 0x8C, 0xB5, 0x90, 0xA4, 0x05, 0x65,
        0x4B, 0xA8, 0xD3, 0xA7, 0x18, 0xD3, 0xA8, 0xFA
    };

    DataRef testData(TestDataRaw, TestDataRaw + sizeof(TestDataRaw));
    DataRefInStream encryptedIn(testData);

    CryptoInStream cryptIn(encryptedIn, "wrong", "");

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kBadHmac);
}

TEST(Crypto, AesCryptReadSequential)
{
    // Same hello_world.txt v3 data, read one byte at a time.
    const uint8_t TestDataRaw[] =
    {
        0x41, 0x45, 0x53, 0x03, 0x00, 0x00, 0x1F, 0x43, 0x52, 0x45, 0x41, 0x54,
        0x45, 0x44, 0x5F, 0x42, 0x59, 0x00, 0x61, 0x65, 0x73, 0x63, 0x72, 0x79,
        0x70, 0x74, 0x5F, 0x63, 0x6C, 0x69, 0x20, 0x34, 0x2E, 0x30, 0x2E, 0x30,
        0x2E, 0x30, 0x00, 0x00, 0x00, 0x04, 0x93, 0xE0, 0x94, 0x70, 0x21, 0xF8,
        0xEE, 0xB3, 0x2E, 0xA4, 0x4E, 0xA8, 0x23, 0x72, 0x0A, 0x91, 0x2A, 0x18,
        0xD5, 0xEC, 0x63, 0xF1, 0x41, 0x7B, 0x77, 0x37, 0xB0, 0x0C, 0x45, 0x0C,
        0xE3, 0xA6, 0xCE, 0x10, 0x77, 0x89, 0x78, 0x95, 0xED, 0x48, 0xB4, 0x56,
        0x7A, 0x36, 0x04, 0x62, 0xFB, 0x24, 0x2D, 0x5C, 0x8A, 0xBC, 0x44, 0x8D,
        0x47, 0x85, 0x2E, 0xEB, 0x9D, 0xC3, 0xB7, 0x91, 0x1F, 0x4B, 0xF0, 0x02,
        0xE9, 0xEE, 0x26, 0xBF, 0xEA, 0x2F, 0xFC, 0x47, 0x12, 0xD3, 0x61, 0x98,
        0x85, 0x50, 0x53, 0x45, 0xF5, 0x35, 0x73, 0x63, 0xD9, 0x0B, 0x6A, 0x2F,
        0xAC, 0x2B, 0x37, 0xD1, 0xDB, 0x8F, 0x34, 0xF6, 0x06, 0xA2, 0xDE, 0x1E,
        0x8C, 0x66, 0x2A, 0x94, 0xC0, 0x3B, 0x15, 0xFD, 0xF9, 0x4A, 0xCE, 0x23,
        0x83, 0x5B, 0x90, 0x9E, 0x3F, 0xEF, 0x96, 0xA7, 0x07, 0x14, 0x11, 0xFD,
        0x72, 0x51, 0x78, 0x62, 0xCB, 0x00, 0x8C, 0xB5, 0x90, 0xA4, 0x05, 0x65,
        0x4B, 0xA8, 0xD3, 0xA7, 0x18, 0xD3, 0xA8, 0xFA
    };

    DataRef testData(TestDataRaw, TestDataRaw + sizeof(TestDataRaw));
    DataRefInStream encryptedIn(testData);

    CryptoInStream cryptIn(encryptedIn, "apples", "");

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kReading);

    std::array<uint8_t, 1> buffer;
    ArrayOutStream         bufferOut(buffer);

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'H');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'e');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'l');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'l');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'o');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], ',');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], ' ');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'W');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'o');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'r');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'l');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], 'd');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.read(bufferOut, 1), 1);
    ASSERT_EQ(buffer[0], '!');
    bufferOut.reset();

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kValidated);
}

TEST(Crypto, AesCryptTruncated)
{
    // Same hello_world.txt v3 data with the last byte removed.
    const uint8_t TestDataRaw[] =
    {
        0x41, 0x45, 0x53, 0x03, 0x00, 0x00, 0x1F, 0x43, 0x52, 0x45, 0x41, 0x54,
        0x45, 0x44, 0x5F, 0x42, 0x59, 0x00, 0x61, 0x65, 0x73, 0x63, 0x72, 0x79,
        0x70, 0x74, 0x5F, 0x63, 0x6C, 0x69, 0x20, 0x34, 0x2E, 0x30, 0x2E, 0x30,
        0x2E, 0x30, 0x00, 0x00, 0x00, 0x04, 0x93, 0xE0, 0x94, 0x70, 0x21, 0xF8,
        0xEE, 0xB3, 0x2E, 0xA4, 0x4E, 0xA8, 0x23, 0x72, 0x0A, 0x91, 0x2A, 0x18,
        0xD5, 0xEC, 0x63, 0xF1, 0x41, 0x7B, 0x77, 0x37, 0xB0, 0x0C, 0x45, 0x0C,
        0xE3, 0xA6, 0xCE, 0x10, 0x77, 0x89, 0x78, 0x95, 0xED, 0x48, 0xB4, 0x56,
        0x7A, 0x36, 0x04, 0x62, 0xFB, 0x24, 0x2D, 0x5C, 0x8A, 0xBC, 0x44, 0x8D,
        0x47, 0x85, 0x2E, 0xEB, 0x9D, 0xC3, 0xB7, 0x91, 0x1F, 0x4B, 0xF0, 0x02,
        0xE9, 0xEE, 0x26, 0xBF, 0xEA, 0x2F, 0xFC, 0x47, 0x12, 0xD3, 0x61, 0x98,
        0x85, 0x50, 0x53, 0x45, 0xF5, 0x35, 0x73, 0x63, 0xD9, 0x0B, 0x6A, 0x2F,
        0xAC, 0x2B, 0x37, 0xD1, 0xDB, 0x8F, 0x34, 0xF6, 0x06, 0xA2, 0xDE, 0x1E,
        0x8C, 0x66, 0x2A, 0x94, 0xC0, 0x3B, 0x15, 0xFD, 0xF9, 0x4A, 0xCE, 0x23,
        0x83, 0x5B, 0x90, 0x9E, 0x3F, 0xEF, 0x96, 0xA7, 0x07, 0x14, 0x11, 0xFD,
        0x72, 0x51, 0x78, 0x62, 0xCB, 0x00, 0x8C, 0xB5, 0x90, 0xA4, 0x05, 0x65,
        0x4B, 0xA8, 0xD3, 0xA7, 0x18, 0xD3, 0xA8
    };

    DataRef testData(TestDataRaw, TestDataRaw + sizeof(TestDataRaw));
    DataRefInStream encryptedIn(testData);

    CryptoInStream cryptIn(encryptedIn, "apples", "");

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kReading);
    
    std::array<uint8_t, 1024> data;
    ArrayOutStream dataOut(data);

    cryptIn.read(dataOut, 1024);

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kTruncated);
}

TEST(Crypto, AesCryptBadDataHmac)
{
    // Same hello_world.txt v3 data with the last byte of the data HMAC corrupted.
    const uint8_t TestDataRaw[] =
    {
        0x41, 0x45, 0x53, 0x03, 0x00, 0x00, 0x1F, 0x43, 0x52, 0x45, 0x41, 0x54,
        0x45, 0x44, 0x5F, 0x42, 0x59, 0x00, 0x61, 0x65, 0x73, 0x63, 0x72, 0x79,
        0x70, 0x74, 0x5F, 0x63, 0x6C, 0x69, 0x20, 0x34, 0x2E, 0x30, 0x2E, 0x30,
        0x2E, 0x30, 0x00, 0x00, 0x00, 0x04, 0x93, 0xE0, 0x94, 0x70, 0x21, 0xF8,
        0xEE, 0xB3, 0x2E, 0xA4, 0x4E, 0xA8, 0x23, 0x72, 0x0A, 0x91, 0x2A, 0x18,
        0xD5, 0xEC, 0x63, 0xF1, 0x41, 0x7B, 0x77, 0x37, 0xB0, 0x0C, 0x45, 0x0C,
        0xE3, 0xA6, 0xCE, 0x10, 0x77, 0x89, 0x78, 0x95, 0xED, 0x48, 0xB4, 0x56,
        0x7A, 0x36, 0x04, 0x62, 0xFB, 0x24, 0x2D, 0x5C, 0x8A, 0xBC, 0x44, 0x8D,
        0x47, 0x85, 0x2E, 0xEB, 0x9D, 0xC3, 0xB7, 0x91, 0x1F, 0x4B, 0xF0, 0x02,
        0xE9, 0xEE, 0x26, 0xBF, 0xEA, 0x2F, 0xFC, 0x47, 0x12, 0xD3, 0x61, 0x98,
        0x85, 0x50, 0x53, 0x45, 0xF5, 0x35, 0x73, 0x63, 0xD9, 0x0B, 0x6A, 0x2F,
        0xAC, 0x2B, 0x37, 0xD1, 0xDB, 0x8F, 0x34, 0xF6, 0x06, 0xA2, 0xDE, 0x1E,
        0x8C, 0x66, 0x2A, 0x94, 0xC0, 0x3B, 0x15, 0xFD, 0xF9, 0x4A, 0xCE, 0x23,
        0x83, 0x5B, 0x90, 0x9E, 0x3F, 0xEF, 0x96, 0xA7, 0x07, 0x14, 0x11, 0xFD,
        0x72, 0x51, 0x78, 0x62, 0xCB, 0x00, 0x8C, 0xB5, 0x90, 0xA4, 0x05, 0x65,
        0x4B, 0xA8, 0xD3, 0xA7, 0x18, 0xD3, 0xA8, 0xFB  // last byte flipped 0xFA->0xFB
    };

    DataRef testData(TestDataRaw, TestDataRaw + sizeof(TestDataRaw));
    DataRefInStream encryptedIn(testData);

    CryptoInStream cryptIn(encryptedIn, "apples", "");

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kReading);
    
    std::array<uint8_t, 1024> data;
    ArrayOutStream dataOut(data);

    cryptIn.read(dataOut, 1024);

    ASSERT_EQ(cryptIn.state(), CryptoInStream::State::kBadDataHmac);
}

// ---- CryptoInStream header/version/reserved error states ----

TEST(Crypto, InStreamBadHeader)
{
    // Magic bytes are not "AES".
    const uint8_t raw[] = { 0x41, 0x45, 0x54 };   // "AET"
    DataRefInStream is(DataRef(raw, raw + sizeof(raw)));
    CryptoInStream cis(is, "test", "_kitchenSink");
    ASSERT_EQ(cis.state(), CryptoInStream::State::kBadHeader);
}

TEST(Crypto, InStreamBadVersion)
{
    // Magic "AES" followed by version 0x01 instead of 0x03.
    const uint8_t raw[] = { 0x41, 0x45, 0x53, 0x01 };
    DataRefInStream is(DataRef(raw, raw + sizeof(raw)));
    CryptoInStream cis(is, "test", "_kitchenSink");
    ASSERT_EQ(cis.state(), CryptoInStream::State::kBadVersion);
}

TEST(Crypto, InStreamCorrupted)
{
    // Magic + version correct, but reserved byte is non-zero.
    const uint8_t raw[] = { 0x41, 0x45, 0x53, 0x03, 0x01 };
    DataRefInStream is(DataRef(raw, raw + sizeof(raw)));
    CryptoInStream cis(is, "test", "_kitchenSink");
    ASSERT_EQ(cis.state(), CryptoInStream::State::kCorrupted);
}

// ---- CryptoOutStream state machine ----

TEST(Crypto, OutStreamInitialState)
{
    srand(42);

    Crypto::IV iv, dataIv;
    Crypto::Key dataKey;
    for (auto& x : iv)     x = uint8_t(rand() & 0xff);
    for (auto& x : dataIv)  x = uint8_t(rand() & 0xff);
    for (auto& x : dataKey) x = uint8_t(rand() & 0xff);

    std::array<uint8_t, 1024> encryptedData;
    ArrayOutStream encryptedOut(encryptedData);

    CryptoOutStream cryptOut(encryptedOut, "test", "_kitchenSink", iv, dataIv, dataKey);

    ASSERT_EQ(cryptOut.state(), CryptoOutStream::State::kWriting);

    const uint8_t payload[] = { 'A', 'B', 'C' };
    cryptOut.write(DataRef(payload, payload + sizeof(payload)));

    // State should still be kWriting until the stream is flushed (on destruction).
    ASSERT_EQ(cryptOut.state(), CryptoOutStream::State::kWriting);
}

// ---- Boundary payload sizes (roundtrip) ----

TEST(Crypto, OneByte)
{
    // Minimum non-empty payload: one partial block.
    const uint8_t raw[] = { 0xAB };
    DataRef testData(raw, raw + sizeof(raw));
    sanityCheck(testData, "test", 1001);
}

TEST(Crypto, FifteenBytes)
{
    // Largest payload that fits in exactly one partial block.
    const uint8_t raw[] = {
        0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
        0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e
    };
    DataRef testData(raw, raw + sizeof(raw));
    sanityCheck(testData, "test", 1002);
}

TEST(Crypto, SeventeenBytes)
{
    // One full block from write(), plus one partial block from flush().
    const uint8_t raw[] = {
        0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
        0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
        0x10
    };
    DataRef testData(raw, raw + sizeof(raw));
    sanityCheck(testData, "test", 1003);
}

TEST(Crypto, ThirtyTwoBytes)
{
    // Exactly two full blocks, nothing left for flush().
    const uint8_t raw[] = {
        0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
        0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
        0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
        0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f
    };
    DataRef testData(raw, raw + sizeof(raw));
    sanityCheck(testData, "test", 1004);
}
